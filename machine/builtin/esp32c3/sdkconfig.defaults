## machine/builtin/esp32c3/sdkconfig.defaults
```kconfig
CONFIG_APP_BUILD_TYPE_RAM=y
CONFIG_APP_BUILD_TYPE_PURE_RAM_APP=y
CONFIG_ESP_CONSOLE_USB_SERIAL_JTAG=y
```
